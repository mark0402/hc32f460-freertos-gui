# Keil uVision project HC32F460Template.uvprojx, settings and files
target HC32F460Template (6190000::V6.19::ARMCLANG)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HC32F460Template +hex
  AfterMake: keil-build-viewer.exe
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=5
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\..\mcu\common;..\source;..\..\driver\inc;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\MDK;..\User;..\..\GUIslice-master\src;..\source\guislice;..\FreeRTOS-Plus\CLI
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f46x.s
    ../../mcu/common/: system_hc32f46x.c
  group source
    ../source/: main.c console.c gpio_out.c gpio_input.c bsp_key.c bsp_led.c app_time.c nv_store.c chinese_font.c chinese_font_data.c tftlcd.c
    ../../GUIslice-master/src/: GUIslice.c
    ../source/guislice/: gslc_drv_hc32.c gui.c
  group User
    ../User/: RTOSThread.c
  group driver
    ../../driver/src/: hc32f46x_icg.c hc32f46x_utility.c hc32f46x_clk.c hc32f46x_efm.c hc32f46x_rtc.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_sram.c hc32f46x_pwc.c hc32f46x_usart.c hc32f46x_spi.c hc32f46x_dmac.c hc32f46x_timer0.c
  group FreeRtos
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/MDK/: port.c
  group FreeRTOS-Plus
    ../FreeRTOS-Plus/CLI/: FreeRTOS_CLI.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
